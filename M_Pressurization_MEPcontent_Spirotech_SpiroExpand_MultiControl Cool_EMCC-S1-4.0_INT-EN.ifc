Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool_EMCC-S1-4.0_INT-EN.ifc
Time: 2025-08-05T18:20:43+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool_INT-EN:EMCC-S1-4.0, M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool_INT-EN:EMCC-S1-4.0:1790054
In: F00
Type - Material: Color RGB 200-000-000, Color RGB 200-200-200, Color RGB 181-166-066, color RGB 115-115-115, Color RGB 255-255-255, Color RGB 040-040-040, Color RAL 1003, Color RGB 055-055-055
Type - Other - Category: Mechanical Equipment; Family Name: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool_INT-EN; Total Length: 460 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 830 mm; Height: 1149 mm; Hydronic Diameter: 25.4 mm; Rear Diameter: 19.05 mm; Refill Diameter: 12.7 mm; Use Nominal Diameter: yes; Width: 406 mm
Type - Electrical Engineering - Voltage: 230 V
Type - Electrical - Loads - Power: 600 W
Type - Identity Data - Article Description: MultiControl Cool Control Solo1 - 4.0 bar; Article Type: EMCC-S1-4.0; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: MultiControl Cool Control Solo1 - 4.0 bar; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811047422; Manufacturer: Spirotech; Manufacturer Art. No.: EMCC-S1-4.0; Manufacturer URL: https://www.spirotech.com/8717811047422; MEPcontent Class: VACUUM_DEGASSER; Model: EMCC-S1-4.0; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCC-S1-4.0; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Blue: Color RGB 000-100-200; Dark Grey: color RGB 115-115-115; Grey: Color RGB 200-200-200; Light Black: Color RGB 055-055-055; Red: Color RGB 200-000-000; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCC-S1-4.0; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EMCC-S1-4.0
Other - Angle: 0 deg; Back Clearance Safe: 0 mm; Family: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool_INT-EN; Family and Type: M_Pressurization_MEPcontent_Spirotech_SpiroExpand_MultiControl Cool_INT-EN: EMCC-S1-4.0; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Left Side Pipe: 238 mm; Reference Line Length: 538 mm; Right Clearance Safe: 500 mm; Right Side Pipe: 202 mm; Top Clearance Safe: 500 mm; Type: EMCC-S1-4.0; Type Id: 1790029; Unit Array: 4
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 8.02437 m2; Volume: 0.192101 m3
Identity Data - Mark: 4
Mechanical - Flow In: 0 m3/s; Flow In 2: 0 m3/s; Flow Out: 0 m3/s; Refill Flow: 0 m3/s; Suction Flow: 0 m3/s; System Classification: Undefined,Power,Undefined
Phasing - Phase Created: 3. New Construction
Visibility - Back Clearance: 0 mm; Front Clearance: 500 mm; Left Clearance: 500 mm; Left Side Connection: no; Right Clearance: 500 mm; Right Side Connection: yes; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (6)
Description: Flow
Name | FlowDirection | PredefinedType
InPort_1790054_7 | SINK | PIPE
Port_1790054_10 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
InPort_1790054_13 | SINK | PIPE
OutPort_1790054_14 | SOURCE | PIPE
InPort_1790054_15 | SINK | PIPE
OutPort_1790054_16 | SOURCE | PIPE
